# Keil uVision project ethernet_bootloader.uvproj, settings and files
target MCB2300 Board (ARM-ADS)
  device: LPC2364 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40001FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ethernet_bootloader +hex
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000040 size 0x1fc0
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup
    ./startup/: LPC2300.s
    ./: sbl_config.h
  group Board Init
    ./board_init/: board_init.c
  group Main
    ./: sbl_main.c comms.c
  group ISP
    ./isp/: isp_iap.c
  group EMAC
    ./ethernet/: emac.c
  group Debug
    ./Debug/: uart.c
  group Timer
    ./timer/: timer.c
